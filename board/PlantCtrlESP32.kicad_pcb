# Repository 0110/PlantCtrl

File README.md:

# PlantCtrl

The following problems shall be solved with this project:
* Solar Powered
* Low Powered
* Plant monitoring
* Plant watering
* IoT

# Hardware
Open hardware design (powered by KiCAD).
The complete PCB is stored in the ***board*** sub directory.

There the following components are connected:
* ESP32 **16MB flash required**
* Lipo monitoring (DS2438)
* 7 moist sensors
* 7 pump
* DC-DC convert (generating voltage from Lipo for pumps)
* DS18B20 temperature sensors
* water level via laser distance sensor (VL53L0X)
* DS2438 battery monitor
* general purpose expansion pins

# Software
The firmware for the controller is stored in ***esp32*** sub directory.

## KiCad design board/PlantCtrlESP32.kicad_pcb

File board/ReadMe.md:

# ESP32 Plant Control Board

The board was built with manily through hole components for easy build and production with a mill.

## GPIO Mapping
See in the parent folder at **include/ControllerConfiguration.h**

## Routing
In order to use the the mill, the following parameter were used:
* Clearance 0.2mm
* Track width of 1.2mm or 1.0mm at minimum (when pins of a part are too close)

Board: 4 copper layers, 99.1 x 99.1 mm, 405 parts (307 on the bottom side), 232 nets.

Parts:
1WIRE1: Conn_01x03; JST_EH_B3B-EH-A_1x03_P2.50mm_Vertical
Boot1: Boot; SW_SPST_CK_RS282G05A3
C1, C2, C5, C10, C11, C12, C15, C18, C19, C20, C29, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C42, C43, C44, C45, C46, C47, C48, C49, C50, C51, C52, C53, C54, C55, C56, C57, C58, C59, C60, C61, C62, C63, C64, C65, C66, C67, C68, C69, C70, C78: 100n; C_0603_1608Metric
C3, C4, C6, C7, C8, C14, C21, C22, C23, C24, C25, C26: 22uf; C_0805_2012Metric
C9, C76, C79: 47uF 30v; CP_Radial_D5.0mm_P2.00mm
C13, C27: 10uF; C_1206_3216Metric
C16, C28: 100nF; C_0603_1608Metric
C17, C30, C31, C71: 22uF; C_1206_3216Metric
C72: 100pf; C_0603_1608Metric
C73: 100nF; C_0805_2012Metric
C74: 200nF; C_0603_1608Metric
C75: C; C_1210_3225Metric
C77: C; C_1206_3216Metric
CTimer1: 100n; C_0603_1608Metric
D1: 7v zehner; D_SOD-123
D2: YELLOW; LED_0603_1608Metric
D3, D5, D6, D7, D8, D9, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D75, D77, D79, D80, D81, D82, D83, D84, D85, D86, D87, D88, D89, D90, D91, D92, D93, D94, D95, D96, D97: BAT54S; SOT-23
D4: 2A 25V; D_SMA
D10: RED; LED_0603_1608Metric
D11, D98: LED; LED_0603_1608Metric
D78: BLUE; LED_0603_1608Metric
D100: SS54; D_SMB
ExtCharge1: Conn_01x02; AMASS_XT30UPB-M_1x02_P5.0mm_Vertical
I2C1: Conn_01x04; JST_EH_B4B-EH-A_1x04_P2.50mm_Vertical
I2C3: GREEN; LED_0603_1608Metric
IsDay1: TestPoint; TestPoint_Pad_2.0x2.0mm
J2: Conn_01x03_Female; PinHeader_1x03_P2.54mm_Vertical
J3: Conn_01x02_MountingPin; JST_PH_B2B-PH-SM4-TB_1x02-1MP_P2.00mm_Vertical
J4: Conn_01x07; PinHeader_1x07_P2.54mm_Horizontal
L1, L2: 4.7uH; L_1210_3225Metric
L3: 47uH; L_12x12mm_H4.5mm
LIGHT1: Conn_01x02; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
PUMP1, PUMP2, PUMP3, PUMP4, PUMP5, PUMP6, PUMP7, PUMP8, PUMP9: Conn_01x02; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
PUMP_D1, PUMP_D2, PUMP_D3, PUMP_D4, PUMP_D5, PUMP_D6, PUMP_D7, PUMP_D8: BLUE; LED_0603_1608Metric
P_FAULT1, P_FAULT2, P_FAULT3, P_FAULT4, P_FAULT5, P_FAULT6, P_FAULT7, P_FAULT8: RED; LED_0603_1608Metric
Q1, Q2, Q3, Q4, Q5, Q7, Q8, Q9, Q10, Q11, Q13, Q14: N-channel 30V 5A; SOT-23
Q6: 4435
Q_PWR1: P-channel 50v 4A; SOT-23
R1, R11, R12: 2k2; R_0603_1608Metric
R2, R22, R109: 5k; R_0603_1608Metric
R3, R6, R9, R16, R18, R19, R21, R23, R25, R26, R50, R56, R59, R62, R65, R68, R79, R108, R111: 10k; R_0603_1608Metric
R4, R7, R8, R10, R13, R14, R15, R17, R20, R24, R34, R37, R41, R47, R49, R55, R58, R61, R64, R67, R78, R98, R99, R100, R101, R102, R103, R104, R105, R107, R110, R113, R116, R119, R122, R125, R128, R131, R134, R137, R138, R140, R143, R146, R149, R152, R155, R158, R161, R164, R167, R170: 1k; R_0603_1608Metric
R5, R106: 2.2Ohm (90mW loss); R_0603_1608Metric
R27: 2.491K; R_0603_1608Metric
R28: 120; R_0603_1608Metric
R29: 50; R_0603_1608Metric
R30, R31: 34k; R_0603_1608Metric
R32: 2.491k; R_0603_1608Metric
R33: 0.06; R_Shunt_Vishay_WSK2512_6332Metric_T1.19mm
RV1: 50k; Potentiometer_Bourns_3299W_Vertical
Reset1: SW_Push; SW_SPST_CK_RS282G05A3
SD1, SD25, SD26, SD27, SD28, SD29, SD30, SD31, SD32, SD33, SD34, SD35, SD36, SD37, SD38, SD39, SD40, SD41, SD42, SD43, SD44, SD45, SD46, SD47: GREEN; LED_0603_1608Metric
S_A_1, S_A_2, S_A_3, S_A_4, S_A_5, S_A_6, S_A_7, S_A_8: Conn_01x02_MountingPin; JST_PH_B2B-PH-SM4-TB_1x02-1MP_P2.00mm_Vertical
S_B_1, S_B_2, S_B_3, S_B_4, S_B_5, S_B_6, S_B_7, S_B_8: Conn_01x02_MountingPin; JST_PH_B2B-PH-SM4-TB_1x02-1MP_P2.00mm_Vertical
S_P_1, S_P_2, S_P_3, S_P_4, S_P_5, S_P_6, S_P_7, S_P_8: Conn_01x02_MountingPin; JST_PH_B2B-PH-SM4-TB_1x02-1MP_P2.00mm_Vertical
SolarIn2: Conn_01x02_Pin; AMASS_XT30UPB-M_1x02_P5.0mm_Vertical
TP8: LED-Enabled; TestPoint_Pad_2.0x2.0mm
TP25: TestPoint; TestPoint_Pad_2.0x2.0mm
U1, U3, U7, U8, U9: 74HC595; SOP-16_3.9x9.9mm_P1.27mm
U2, U10, U11, U12, U13, U14, U15, U16, U17, U18, U19, U20, U21, U23, U24, U25, U26, U27, U28, U29, U30, U31, U32, U33: TLC555xP; SO-8_3.9x4.9mm_P1.27mm
U4: ESP32-WROOM-32D; ESP32-WROOM-32
U5: AP63200; TSOT-23-6
U6: CN3795; SSOP10
U22: AP63203; TSOT-23-6
U34: LM74700; SOT-23-6
U36: PC817; DIP-4_W7.62mm
battery1: Conn_01x02_Socket; AMASS_XT30UPB-F_1x02_P5.0mm_Vertical

Connections:
1K_GND: R138.2, SD1.1 (K), SD25.1 (K), SD26.1 (K), SD27.1 (K), SD28.1 (K), SD29.1 (K), SD30.1 (K), SD31.1 (K), SD32.1 (K), SD33.1 (K), SD34.1 (K), SD35.1 (K), SD36.1 (K), SD37.1 (K), SD38.1 (K), SD39.1 (K), SD40.1 (K), SD41.1 (K), SD42.1 (K), SD43.1 (K), SD44.1 (K), SD45.1 (K), SD46.1 (K), SD47.1 (K)
3_3V: 1WIRE1.3, C2.2, C3.1, C30.1, C31.1, D3.2, D6.2, D8.2, D13.2, D14.2, D15.2, D16.2, D17.2, D18.2, D20.2, D22.2, D24.2, D27.2, D29.2, D31.2, D34.2, D35.1, D36.1, D37.1, D38.1, D39.2, D40.2, D41.2, D42.2, D43.2, D44.2, D45.2, D46.2, D47.2, D48.2, D49.2, D50.2, D51.2, D52.2, D53.2, D54.2, D55.2, D56.2, D57.2, D58.2, D59.2, D60.2, D61.2, D62.2, D63.2, D64.2, D65.2, D66.2, D67.2, D68.2, D69.2, D70.2, D71.2, D72.2, D73.2, D74.2, D75.2, I2C1.1, J4.3, L1.2, R1.1, R11.1, R12.1, R15.2, R16.2, R29.2, R79.1, U1.16 (VCC), U3.16 (VCC), U4.2 (VDD), U7.16 (VCC), U8.16 (VCC), U9.16 (VCC), U22.1 (FB)
5K_VBAT: PUMP_D1.2 (A), PUMP_D2.2 (A), PUMP_D3.2 (A), PUMP_D4.2 (A), PUMP_D5.2 (A), PUMP_D6.2 (A), PUMP_D7.2 (A), PUMP_D8.2 (A), R109.2
/3_3IN: C27.1, R106.2, U22.2 (EN), U22.3 (IN)
/3_3V_cool: C28.2, L1.1, U22.5 (SW)
/Light+: C17.1, C71.1, C72.1, L2.2, LIGHT1.2, R23.1
/Light_In: C13.1, R5.2, U5.2 (EN), U5.3 (IN)
/Light_cool: C16.2, L2.1, U5.5 (SW)
CentralPump: D77.3, D78.1 (K), PUMP9.1, Q1.3 (D)
Clock: D37.3, J4.6, U1.11 (SRCLK), U3.11 (SRCLK), U4.33 (IO21), U7.11 (SRCLK), U8.11 (SRCLK), U9.11 (SRCLK)
ENABLE_TANK: R8.2, U4.12 (IO27)
ESP_RX: J2.3, U4.34 (RXD0/IO3)
ESP_TX: J2.2, U4.35 (TXD0/IO1)
GND: 1WIRE1.1, Boot1.1, C1.1, C2.1, C3.2, C4.1, C5.1, C6.1, C7.2, C8.2, C9.2, C10.2, C11.1, C12.2, C13.2, C14.2, C15.1, C17.2, C18.2, C19.1, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C29.1, C30.2, C31.2, C32.1, C33.2, C34.1, C35.2, C36.1, C37.2, C38.1, C39.2, C40.1, C41.2, C42.1, C43.2, C44.1, C45.2, C46.1, C47.2, C48.1, C49.2, C50.1, C51.2, C52.1, C53.2, C54.1, C55.2, C56.1, C57.2, C58.1, C59.2, C60.1, C61.2, C62.1, C63.2, C64.1, C65.2, C66.1, C67.2, C68.1, C69.2, C70.1, C71.2, C74.2, C75.2, C76.2, C77.2, C79.2, CTimer1.2, D3.1, D5.1, D6.1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
IsDay: IsDay1.1, R78.1, R79.2, U4.10 (IO25)
LED_ENABLE: R7.2, TP8.1, U4.11 (IO26)
Latch: D38.3, J4.7, U1.12 (RCLK), U3.12 (RCLK), U4.36 (IO22), U7.12 (RCLK), U8.12 (RCLK), U9.12 (RCLK)
unnamed: Boot1.2, C1.2, R13.2
unnamed: C5.2, R17.2, Reset1.2
unnamed: C74.1, R28.2
unnamed: D1.2 (A), U36.1
unnamed: D2.2 (A), U4.16 (IO13)
unnamed: D2.1 (K), R10.1
unnamed: D4.2 (A), D10.2 (A), ExtCharge1.2
unnamed: D10.1 (K), R9.2
unnamed: D11.2 (A), R26.1
unnamed: D12.1 (A), R137.1, U21.3 (Q)
unnamed: D19.1 (A), R140.1, U23.3 (Q)
unnamed: D21.1 (A), R143.1, U24.3 (Q)
unnamed: D23.1 (A), R146.1, U25.3 (Q)
unnamed: D26.1 (A), R149.1, U26.3 (Q)
unnamed: D78.2 (A), R2.2
unnamed: D79.1 (A), R152.1, U27.3 (Q)
unnamed: D80.1 (A), R155.1, U28.3 (Q)
unnamed: D81.1 (A), R158.1, U29.3 (Q)
unnamed: D82.1 (A), R161.1, U30.3 (Q)
unnamed: D83.1 (A), R164.1, U31.3 (Q)
unnamed: D84.1 (A), R167.1, U32.3 (Q)
unnamed: D85.1 (A), R170.1, U33.3 (Q)
unnamed: D86.1 (A), R34.1, U10.3 (Q)
unnamed: D87.1 (A), R37.1, U11.3 (Q)
unnamed: D88.1 (A), R41.1, U12.3 (Q)
unnamed: D89.1 (A), R47.1, U13.3 (Q)
unnamed: D90.1 (A), R113.1, U2.3 (Q)
unnamed: D91.1 (A), R116.1, U14.3 (Q)
unnamed: D92.1 (A), R119.1, U15.3 (Q)
unnamed: D93.1 (A), R122.1, U16.3 (Q)
unnamed: D94.1 (A), R125.1, U17.3 (Q)
unnamed: D95.1 (A), R128.1, U18.3 (Q)
unnamed: D96.1 (A), R131.1, U19.3 (Q)
unnamed: D97.1 (A), R134.1, U20.3 (Q)
unnamed: D98.2 (A), R25.2
unnamed: D98.1 (K), U6.3 (~CHRG)
unnamed: D100.1 (K), L3.1, Q6.1 (D)
unnamed: I2C3.2 (A), R22.2
unnamed: D24.3, J3.1, Q4.3 (D)
unnamed: L3.2, R33.1
unnamed: D25.3, PUMP1.1, PUMP_D1.1 (K), Q5.3 (D)
unnamed: D5.3, PUMP2.1, PUMP_D2.1 (K), Q14.3 (D)
unnamed: D7.3, PUMP3.1, PUMP_D3.1 (K), Q7.3 (D)
unnamed: D9.3, PUMP4.1, PUMP_D4.1 (K), Q8.3 (D)
unnamed: D28.3, PUMP5.1, PUMP_D5.1 (K), Q9.3 (D)
unnamed: D30.3, PUMP6.1, PUMP_D6.1 (K), Q10.3 (D)
unnamed: D32.3, PUMP7.1, PUMP_D7.1 (K), Q11.3 (D)
unnamed: D33.3, PUMP8.1, PUMP_D8.1 (K), Q13.3 (D)
unnamed: P_FAULT1.2 (A), U1.1 (QB)
unnamed: P_FAULT1.1 (K), R98.2
unnamed: P_FAULT2.2 (A), U1.6 (QG)
unnamed: P_FAULT2.1 (K), R99.2
unnamed: P_FAULT3.2 (A), U3.3 (QD)
unnamed: P_FAULT3.1 (K), R100.2
unnamed: P_FAULT4.2 (A), U7.15 (QA)
unnamed: P_FAULT4.1 (K), R101.2
unnamed: P_FAULT5.2 (A), U7.5 (QF)
unnamed: P_FAULT5.1 (K), R102.2
unnamed: P_FAULT6.2 (A), U8.2 (QC)
unnamed: P_FAULT6.1 (K), R103.2
unnamed: P_FAULT7.2 (A), U8.7 (QH)
unnamed: P_FAULT7.1 (K), R104.2
unnamed: P_FAULT8.2 (A), U9.4 (QE)
unnamed: P_FAULT8.1 (K), R105.2
unnamed: Q1.1 (G), R3.1, R4.2
unnamed: Q2.3 (D), R20.2
unnamed: Q2.1 (G), R7.1, R19.1
unnamed: Q3.1 (G), U34.5 (GATE)
unnamed: C75.1, C76.1, C78.1, Q3.2 (S), R33.4, U34.3 (EN), U34.6 (ANODE)
unnamed: Q4.1 (G), R8.1, R18.1
unnamed: Q5.1 (G), R49.2, R50.1
unnamed: Q6.2 (G), U6.10 (DRV)
unnamed: Q7.1 (G), R55.2, R56.1
unnamed: Q8.1 (G), R58.2, R59.1
unnamed: Q9.1 (G), R61.2, R62.1
unnamed: Q10.1 (G), R64.2, R65.1
unnamed: Q11.1 (G), R67.2, R68.1
unnamed: Q13.1 (G), R107.2, R108.1
unnamed: Q14.1 (G), R110.2, R111.1
unnamed: Q_PWR1.3 (D), R5.1, R22.1
unnamed: Q_PWR1.1 (G), R20.1, R21.1
unnamed: R14.2, R15.1
unnamed: R24.2, RV1.1
unnamed: R26.2, U36.2
unnamed: R78.2, U36.4
unnamed: C10.1, D14.3, S_A_1.1, U10.2 (TR), U10.6 (THR)
unnamed: D15.3, R34.2, S_A_1.2
unnamed: C20.1, D22.3, S_A_2.1, U13.2 (TR), U13.6 (THR)
unnamed: D27.3, R47.2, S_A_2.2
unnamed: C37.1, D40.3, S_A_3.1, U16.2 (TR), U16.6 (THR)
unnamed: D41.3, R122.2, S_A_3.2
unnamed: C43.1, D46.3, S_A_4.1, U19.2 (TR), U19.6 (THR)
unnamed: D47.3, R131.2, S_A_4.2
unnamed: C49.1, D52.3, S_A_5.1, U23.2 (TR), U23.6 (THR)
unnamed: D53.3, R140.2, S_A_5.2
unnamed: C55.1, D58.3, S_A_6.1, U26.2 (TR), U26.6 (THR)
unnamed: D59.3, R149.2, S_A_6.2
unnamed: C61.1, D64.3, S_A_7.1, U29.2 (TR), U29.6 (THR)
unnamed: D65.3, R158.2, S_A_7.2
unnamed: C67.1, D70.3, S_A_8.1, U32.2 (TR), U32.6 (THR)
unnamed: D71.3, R167.2, S_A_8.2
unnamed: C12.1, D16.3, S_B_1.1, U11.2 (TR), U11.6 (THR)
unnamed: D17.3, R37.2, S_B_1.2
unnamed: C33.1, D29.3, S_B_2.1, U14.2 (TR), U14.6 (THR)
unnamed: D31.3, R116.2, S_B_2.2
unnamed: C39.1, D42.3, S_B_3.1, U17.2 (TR), U17.6 (THR)
unnamed: D43.3, R125.2, S_B_3.2
unnamed: C45.1, D48.3, S_B_4.1, U20.2 (TR), U20.6 (THR)
unnamed: D49.3, R134.2, S_B_4.2
unnamed: C51.1, D54.3, S_B_5.1, U24.2 (TR), U24.6 (THR)
unnamed: D55.3, R143.2, S_B_5.2
unnamed: C57.1, D60.3, S_B_6.1, U27.2 (TR), U27.6 (THR)
unnamed: D61.3, R152.2, S_B_6.2
unnamed: C63.1, D66.3, S_B_7.1, U30.2 (TR), U30.6 (THR)
unnamed: D67.3, R161.2, S_B_7.2
unnamed: C69.1, D72.3, S_B_8.1, U33.2 (TR), U33.6 (THR)
unnamed: D73.3, R170.2, S_B_8.2
unnamed: CTimer1.1, D6.3, S_P_1.1, U2.2 (TR), U2.6 (THR)
unnamed: D8.3, R113.2, S_P_1.2
unnamed: C18.1, D18.3, S_P_2.1, U12.2 (TR), U12.6 (THR)
unnamed: D20.3, R41.2, S_P_2.2
unnamed: C35.1, D34.3, S_P_3.1, U15.2 (TR), U15.6 (THR)
unnamed: D39.3, R119.2, S_P_3.2
unnamed: C41.1, D44.3, S_P_4.1, U18.2 (TR), U18.6 (THR)
unnamed: D45.3, R128.2, S_P_4.2
unnamed: C47.1, D50.3, S_P_5.1, U21.2 (TR), U21.6 (THR)
unnamed: D51.3, R137.2, S_P_5.2
unnamed: C53.1, D56.3, S_P_6.1, U25.2 (TR), U25.6 (THR)
unnamed: D57.3, R146.2, S_P_6.2
unnamed: C59.1, D62.3, S_P_7.1, U28.2 (TR), U28.6 (THR)
unnamed: D63.3, R155.2, S_P_7.2
unnamed: C65.1, D68.3, S_P_8.1, U31.2 (TR), U31.6 (THR)
unnamed: D69.3, R164.2, S_P_8.2
unnamed: U1.9 (QH'), U3.14 (SER)
unnamed: C32.2, U2.5 (CV)
unnamed: U3.9 (QH'), U7.14 (SER)
unnamed: C6.2, R16.1, R17.1, U4.3 (EN)
unnamed: C4.2, R13.1, R14.1, U4.25 (IO0)
unnamed: C16.1, U5.6 (BST)
unnamed: C72.2, R23.2, R24.1, U5.1 (FB)
unnamed: R30.1, R33.3, U6.7 (BAT)
unnamed: R28.1, U6.5 (COM)
unnamed: R33.2, U6.8 (CSP)
unnamed: R30.2, R32.1, U6.6 (FB)
unnamed: R27.2, R31.2, U6.4 (MPPT)
unnamed: C73.2, U6.1 (VG)
unnamed: U7.9 (QH'), U8.14 (SER)
unnamed: U8.9 (QH'), U9.14 (SER)
unnamed: C11.2, U10.5 (CV)
unnamed: C15.2, U11.5 (CV)
unnamed: C19.2, U12.5 (CV)
unnamed: C29.2, U13.5 (CV)
unnamed: C34.2, U14.5 (CV)
unnamed: C36.2, U15.5 (CV)
unnamed: C38.2, U16.5 (CV)
unnamed: C40.2, U17.5 (CV)
unnamed: C42.2, U18.5 (CV)
unnamed: C44.2, U19.5 (CV)
unnamed: C46.2, U20.5 (CV)
unnamed: C48.2, U21.5 (CV)
unnamed: C28.1, U22.6 (BST)
unnamed: C50.2, U23.5 (CV)
unnamed: C52.2, U24.5 (CV)
unnamed: C54.2, U25.5 (CV)
unnamed: C56.2, U26.5 (CV)
unnamed: C58.2, U27.5 (CV)
unnamed: C60.2, U28.5 (CV)
unnamed: C62.2, U29.5 (CV)
unnamed: C64.2, U30.5 (CV)
unnamed: C66.2, U31.5 (CV)
unnamed: C68.2, U32.5 (CV)
unnamed: C70.2, U33.5 (CV)
unnamed: C78.2, U34.1 (VCAP)
PUMP1: R49.1, U1.15 (QA)
PUMP2: R110.1, U1.5 (QF)
PUMP3: R55.1, U3.2 (QC)
PUMP4: R58.1, U3.7 (QH)
PUMP5: R61.1, U7.4 (QE)
PUMP6: R64.1, U8.1 (QB)
PUMP7: R67.1, U8.6 (QG)
PUMP8: R107.1, U9.3 (QD)
PUMP_ENABLE: R4.1, U4.37 (IO23)
SCL: D74.3, I2C1.3, R11.2, U4.27 (IO16)
SDA: D13.3, I2C1.4, R12.2, U4.28 (IO17)
SENSOR1_A: SD25.2 (A), U1.3 (QD), U10.4 (R), U10.8 (VCC)
SENSOR1_B: SD26.2 (A), U1.4 (QE), U11.4 (R), U11.8 (VCC)
SENSOR1_PUMP_END: SD1.2 (A), U1.2 (QC), U2.4 (R), U2.8 (VCC)
SENSOR2_A: SD28.2 (A), U3.15 (QA), U13.4 (R), U13.8 (VCC)
SENSOR2_B: SD29.2 (A), U3.1 (QB), U14.4 (R), U14.8 (VCC)
SENSOR2_PUMP_END: SD27.2 (A), U1.7 (QH), U12.4 (R), U12.8 (VCC)
SENSOR3_A: SD31.2 (A), U3.5 (QF), U16.4 (R), U16.8 (VCC)
SENSOR3_B: SD32.2 (A), U3.6 (QG), U17.4 (R), U17.8 (VCC)
SENSOR3_PUMP_END: SD30.2 (A), U3.4 (QE), U15.4 (R), U15.8 (VCC)
SENSOR4_A: SD34.2 (A), U7.2 (QC), U19.4 (R), U19.8 (VCC)
SENSOR4_B: SD35.2 (A), U7.3 (QD), U20.4 (R), U20.8 (VCC)
SENSOR4_PUMP_END: SD33.2 (A), U7.1 (QB), U18.4 (R), U18.8 (VCC)
SENSOR5_A: SD37.2 (A), U7.7 (QH), U23.4 (R), U23.8 (VCC)
SENSOR5_B: SD38.2 (A), U8.15 (QA), U24.4 (R), U24.8 (VCC)
SENSOR5_PUMP_END: SD36.2 (A), U7.6 (QG), U21.4 (R), U21.8 (VCC)
SENSOR6_A: SD40.2 (A), U8.4 (QE), U26.4 (R), U26.8 (VCC)
SENSOR6_B: SD41.2 (A), U8.5 (QF), U27.4 (R), U27.8 (VCC)
SENSOR6_PUMP_END: SD39.2 (A), U8.3 (QD), U25.4 (R), U25.8 (VCC)
SENSOR7_A: SD43.2 (A), U9.1 (QB), U29.4 (R), U29.8 (VCC)
SENSOR7_B: SD44.2 (A), U9.2 (QC), U30.4 (R), U30.8 (VCC)
SENSOR7_PUMP_END: SD42.2 (A), U9.15 (QA), U28.4 (R), U28.8 (VCC)
SENSOR8_A: SD46.2 (A), U9.6 (QG), U32.4 (R), U32.8 (VCC)
SENSOR8_B: SD47.2 (A), U9.7 (QH), U33.4 (R), U33.8 (VCC)
SENSOR8_PUMP_END: SD45.2 (A), U9.5 (QF), U31.4 (R), U31.8 (VCC)
SIGNAL: D12.3 (COM), D19.3 (COM), D21.3 (COM), D23.3 (COM), D26.3 (COM), D35.3, D79.3 (COM), D80.3 (COM), D81.3 (COM), D82.3 (COM), D83.3 (COM), D84.3 (COM), D85.3 (COM), D86.3 (COM), D87.3 (COM), D88.3 (COM), D89.3 (COM), D90.3 (COM), D91.3 (COM), D92.3 (COM), D93.3 (COM), D94.3 (COM), D95.3 (COM), D96.3 (COM), D97.3 (COM), J4.4, R6.1, TP25.1, U4.30 (IO18)
S_VIN: C9.1, C73.1, C77.1, D1.1 (K), Q6.3 (S), R25.1, R31.1, SolarIn2.1, U6.9 (VCC)
SerialIn: U1.14 (SER), U4.31 (IO19)
SerialOut: D36.3, J4.5, U9.9 (QH')
TANK_SENSOR: D75.3, J3.2, R29.1, U4.5 (SENSOR_VN)
Temp: 1WIRE1.2, D3.3, R1.2, U4.26 (IO4)
VBAT: C7.1, C8.1, C14.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C79.1, D5.2, D7.2, D9.2, D25.2, D28.2, D30.2, D32.2, D33.2, D77.2, J4.2, PUMP1.2, PUMP2.2, PUMP3.2, PUMP4.2, PUMP5.2, PUMP6.2, PUMP7.2, PUMP8.2, PUMP9.2, Q3.3 (D), Q_PWR1.2 (S), R2.1, R21.2, R106.1, R109.1, U34.4 (CATHODE), battery1.2

## KiCad design plantctrl-extension/plantctrl-extension.kicad_pcb

Parts:
3_3V1: Conn_01x02_Female; JST_EH_B2B-EH-A_1x02_P2.50mm_Vertical
D1: VCC; LED_0805_2012Metric; LCSC_PART_NUMBER C205441
D2: 3_3V; LED_0805_2012Metric; LCSC_PART_NUMBER C205441
D3: PUMP; LED_0805_2012Metric; LCSC_PART_NUMBER C205441
D4: GPIO34; LED_0805_2012Metric; LCSC_PART_NUMBER C205441
D5: GPIO35; LED_0805_2012Metric; LCSC_PART_NUMBER C205441
D6: GPIO02; LED_0805_2012Metric; LCSC_PART_NUMBER C205441
D7: GPIO12; LED_0805_2012Metric; LCSC_PART_NUMBER C205441
GPIO34, GPIO35: Conn_01x02_Female; JST_EH_B2B-EH-A_1x02_P2.50mm_Vertical
GPO2, GPO12: Conn_01x02_Female; JST_EH_B2B-EH-A_1x02_P2.50mm_Vertical
J1: Conn_02x04_Counter_Clockwise; PinSocket_2x04_P2.54mm_Vertical
PUMP1: Conn_01x02_Female; JST_EH_B2B-EH-A_1x02_P2.50mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R9: 1k; R_0805_2012Metric; LCSC_PART_NUMBER C95781
TEST1: SW_Push; SW_SPST_CK_RS282G05A3; LCSC_PART_NUMBER C72443
VCC1: Conn_01x02_Female; JST_EH_B2B-EH-A_1x02_P2.50mm_Vertical

Connections:
3_3V: 3_3V1.2, J1.4, R2.2
GND: 3_3V1.1, D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), GPIO34.1, GPIO35.1, GPO2.1, GPO12.1, J1.2, PUMP1.1, TEST1.1, VCC1.1
GPIO02: GPO2.2, J1.5, R6.2
GPIO12: GPO12.2, J1.7, R9.2
GPIO34: J1.1, R4.2, R7.1
GPIO35: J1.3, R5.2, R8.1
unnamed: D1.2 (A), R1.1
unnamed: D2.2 (A), R2.1
unnamed: D3.2 (A), R3.1
unnamed: D4.2 (A), R4.1
unnamed: D5.2 (A), R5.1
unnamed: D6.2 (A), R6.1
unnamed: D7.2 (A), R9.1
unnamed: GPIO34.2, R7.2
unnamed: GPIO35.2, R8.2
unnamed: D1.1 (K), D2.1 (K), TEST1.2
PUMP_PWR: J1.8, PUMP1.2, R3.2
VCC: J1.6, R1.2, VCC1.2

Board: 2 copper layers, 22.2 x 27.9 mm, 25 parts (10 on the bottom side), 18 nets.

## Commit log (part)

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2020-10-16 Updated ignore files
2020-10-16 device is running again
2020-10-16 Read settings and store into non volatile memory
2020-10-16 Upgraded version number
2020-10-18 main decision flow cleanups
2020-10-20 Timer added
2020-10-20 mode cleanup
2020-10-20 Define library dependency for ArduinoJson
2020-10-20 ota debugging attempts
2020-10-20 ota works (for me)
2020-10-20 reduced flash useage by reducing strings
2020-10-20 slimmer website
2020-10-20 reduced settings
2020-10-21 OTA flashing is disabling deepsleep at start
2020-10-21 Status LED for flashing
2020-10-21 Sensor values are written and read in the same variable
2020-10-21 Deep sleep is now working
2020-10-21 settings gpio mode before deepsleep
2020-10-21 set pump output
2020-10-23 More debug output
2020-10-23 Handle default value of cooldown
2020-10-23 * Es gibt lange Leitungen die von der Platine weg gehen. Hier gibt es zwei Risiken: - Sie können sich Hochfrequente Störungen aus der Umgebung einfangen (sie bilden letztlich eine große Antenne) --> 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
2020-10-23 Only Pump safety is not placed
2020-10-28 Pump5 pin corrected
2020-10-28 Disable pumps while OTA running, mode2 is called only once
2020-10-29 Moved more parts arround
2020-10-30 Measure temperatur sensor multiple times
2020-10-30 Enable debugging of onewire lib
2020-10-30 Increased board revision
2020-10-31 SensorPwr for 1Wire routed
2020-10-31 make shit work more
2020-10-31 Adapt time comment
2020-10-31 made deep sleep modes work and behave somewhat correctly, gave mqqt time to publish, gave ntp time to sync
2020-11-01 Fixed plant loop in mode1
2020-11-01 All parts layouted
2020-11-01 NTP Server can be set via configuration item
2020-11-01 Toggle Sensor LED to visualize mode 3
2020-11-04 fixed wrong indes for pump determination improved pump status output fixed led blinking in mode3 random
2020-11-04 added raw moisture, improved pct calc , formating
2020-11-04 improve mode3 not pumping
2020-11-06 Moved ESP32 information into its subdirectory
2020-11-06 Desciption for hardware added
2020-11-06 Struct used for RTC memory
2020-11-06 Added comments for the RTC struct
2020-11-06 Wakeup due to change temperature
2020-11-06 Doxygen added
2020-11-06 Raw ADC value of lipo added
2020-11-07 moved solar connector more to border
2020-11-11 water sensor started
2020-11-11 only read temperature multiple times, if it differs significantly to last measurement
2020-11-11 Read ultrasonnic sensor 5 times
2020-11-11 added lipo protector to schematic
2020-11-11 read only once
2020-11-12 Moved upload port into seperate configuration file
2020-11-25 improved schematic parts
2020-11-27 routing and schematic fixes
2020-11-29 0.4 order files
2020-12-02 fixed wrong mosefets used
2020-12-09 Fixed wakeup due static code analysis
2020-12-09 All static code analyis comments fixed, only TODOs are open
2020-12-09 Added Cppcheck project file for static code analysis
2020-12-12 fixed pin assignements for new revision
2020-12-13 fix one wire detection, allow multiple sensors and set per setting which one is which
2020-12-20 Missed one N-Channel Mosfet
2020-12-20 Fixed Mosfet used to switch Pump and Sensor supply
2020-12-21 Added capacitor for ESP
2020-12-21 Moved PCB stuff into the borad folder
2020-12-21 Described used ultra sonic sensor
2020-12-21 corrected code highlighting
2020-12-21 Used distance reading time to stabilize temperature sensors
2020-12-24 fix for upstepper inductor, fix upstepper diode, fix voltage on pumps when upstepper is off
2020-12-28 Moved J6 under lipo
2020-12-28 Removed deadend wires at S6
2020-12-28 Voltsensor test series has a constant, too
2020-12-28 Fixed one-wire library with an hammer
2020-12-30 Added J8 for USB programming and POWER supply by USB; Lipo has to be disconnected!
2021-01-03 Documentation improved
2021-01-05 Solar charger and lipo protection seperated
2021-01-05 Cleanup
2021-01-05 External 5V no longer exists
2021-01-05 Inductor package adapted
2021-01-05 Added referencal voltages at SENSOR_VP and SENSOR_VN
2021-01-05 swapped moister sensor pins
2021-01-05 Swapped IO15 with IO17
2021-01-05 IC1 VDD is protected by the fuse F1, too
2021-01-05 Described external power supply
2021-01-05 Custom connection connector removed solder jumper and pullup resistor
2021-01-12 ds2435 pcb update
2021-01-13 added alternative lipo connector
2021-01-13 pcb change
2021-01-13 Final 0.7
2021-01-13 fixed LCSC part numbers
2021-01-30 Last minute fixes while assembly
2021-01-30 Swapped GPIO2 with GPIO12
2021-01-30 Added onewire test
2021-01-30 battery manager test code
2021-02-04 Refactored page access: added parameter to specify the page to write or read
2021-02-04 Default page zero described
2021-02-04 Read Page7 and debug print it
2021-02-04 ds2438 stuff, vesense+ and - swapped
2021-02-06 added 1000uF capacitor option
2021-02-09 hall via softserial, vsense wrong direction
2021-02-09 Changed Transistors from THT to SMD
2021-02-09 J1 has now a footprint
2021-02-09 Debug point got footprint
2021-02-09 updated pcb to chematic
2021-02-09 added power supervisor
2021-02-12 use correct footprints for oven soldering
2021-02-16 ds2438 test code works
2021-02-16 added toto regarding crc
2021-02-16 Chip temperature is published, too
2021-02-16 Corrected pin configuration to 0.7final PCB
2021-02-16 expose ica dcd ccd ah values
2021-02-24 Reduced sensor led brightness
2021-03-02 Added serial2 of ESP32 useable for JSN-SR04T-2.0
2021-03-04 Shunt set to 25mOhm
2021-03-04 Pinout ESP32 added
2021-03-04 Started Hallsensor
2021-03-04 added echo code
2021-03-04 0.9 final
2021-04-07 Renamed constants
2021-04-07 Address of tempsensors is published to MQTT
2021-04-07 Handle cooldown time for watering; add start and end time when pumping is allowed
2021-04-07 Reduce frequence of ESP32 to 80Mhz
2021-04-07 One wire is initialized directly after start
2021-04-07 Todos aufgerauemt
2021-04-07 Cleanup unused variables and code
2021-05-16 Describe different buttons should be used
2021-05-16 Nchannel is not Pchannel!
2021-05-16 GPIO12 is evil
2021-05-19 More GPIO debug output added; checking GPIO15, too
2021-05-24 fixed deepsleep procedure, homie shutdown, ensure pinhold is same as pin
2021-05-24 use mqtt roundtrip to ensure all receiving messages are processed before ds
2021-05-24 fixed homie config fail mode
2021-05-26 Handle different start and end times to water plants
2021-05-26 added testmode, fixed formating
2021-05-26 config backup wip
2021-05-27 "improved" topic macro, added backup status and topic
2021-05-28 changed switches to cheaper alternative
2021-05-29 ensure DS18S20 are properly resolved via address
2021-05-29 make sensor address compare actually work
2021-06-01 fixed labeling and spacing for sensors and pumps
2021-06-02 use same pinout for moisture sensor as used on the sensor itself
2021-06-04 reduced odd resistors
2021-06-04 further reduced only once used parts
2021-06-06 fixed bootloader
2021-06-06 added distance sensor and adjusted pcb for it
2021-06-06 report raw distance for water sensor
2021-06-10 new extension header, improved labeling of connectors, optimized layout
2021-06-23 0.10 rev final
2021-06-29 set threshold for accumlator calculation
2021-06-29 adjust voltage divider to match 0.10 pcb layout
2021-06-29 fixed config backup and restore
2021-06-29 initial settings uploader added
2021-07-01 code stuff
2021-07-01 clear averages for each run, ignore distances higher than tank depth
2021-07-01 use mAlive instead of mqtt/homie varaibles
2021-07-01 extracte time stuff, started logger
2021-07-01 Fixed concatination of strings in logging
2021-07-01 fix cooldown memory without power, improved logging
2021-07-09 code cleanups
2021-07-09 react on switch from Mqtt
2021-07-14 Renamed file
2021-07-14 Seperate setting itself into a local file
2021-07-14 adapted datatype
2021-07-21 Reading sensors by frequency
2021-08-17 fixed wrong percent calculation, emit trigger value to mqtt
2021-08-22 add alarm if pumps did not change state to wet after X consecutive tries
2021-08-30 fix for wrong validator
2021-09-14 prevent light from being reenabled untill next day after low voltage trigger
2021-10-01 Updated ini.example
2021-10-01 wip new pump system
2021-10-06 initial flowmeter logic and calculation
2021-10-06 mqtt extraction
2021-10-22 smooth battery sensor
2021-10-22 added initial support for hydroponic systems, changed cooldown to use minutes
2021-10-26 some fixes for hydroponics mode
2021-10-26 added pump specific power level (requires controller that supports this or dc motor)
2021-10-26 fix for hydroponic not working at night
2021-10-26 use only seconds for time units, improve self test debug
2021-10-27 remove selfTest causing sideeffects for pumploop trigger
2021-10-27 increased ota flash sizes
2021-11-13 Exceptions added
2021-11-14 Added time into logs
2021-11-19 pump refactor round 1
2021-11-28 Settings are provided as JSON
2021-11-29 Use only Homie compliant datatypes: https://homieiot.github.io/specification/spec-core-v3_0_1/#
2021-12-02 hydro mode config and ignore low voltage light condition
2021-12-03 basic pump ml calculation
2021-12-05 added ulp-pwm logic for timedlight
2021-12-05 cleanup power settings
2022-02-12 allow sensor type selection per plant, changed calculations to use PCT values, due to different raw value meaning
2022-02-19 fix for capacitive sensors not working, enum introduction for sensormode
2022-03-05 sht20 support
2022-03-06 Update the analog maximum according datasheet
2022-03-06 Sensor types are defined in platformio.ini
2022-04-02 Testsetup for frequency on GPIO17
2022-04-29 use more sane default (pump always not only at night)
2022-04-29 do not use pump for download indication anymore
2022-04-29 formating only
2022-05-19 add timer only mode, more sane default config
2022-06-25 Restore frequency boundaries (7a54065a5fce8c5fd448afce79aca0221c51c6a8)
2022-08-21 Plant states defined in header
2022-08-21 Publish state as number and string
2022-08-21 Version increased
2022-08-21 Tweaked number
2022-08-23 Tweak state numbers
2022-08-25 Ignore voltages above 100V
2022-12-19 set more state retained
2022-12-19 slightly adjust range for better precision
2023-02-10 add resistive frequency sensor, updated dependencies
2023-02-10 fix water error code
2023-02-12 Revert "Revert "add resistive frequency sensor, updated dependencies""
    This reverts commit 42ce4cdda2ae521129661115d4b381f6dfabae46.
2023-03-03 stuff changed
2023-03-10 Removed timeout
2023-03-22 VL53L0X test started
2023-03-22 Print distance
2023-03-22 Reset sensor on bad values
2023-03-22 distance sensor is reset after powercycle
2023-03-22 frequency resistive sensor adjustment
2023-03-24 Fixed water distance and publish percentage
2023-03-24 Stop pumps due to water sensor
2023-04-06 sleep at least several minutes, so the solar panel can charge the battery
2023-04-06 Changed to python3
2023-05-17 added ota state debugging
2023-05-18 added extension board
2023-05-28 Adapted default work time, as internal time is UTC
2023-06-04 Fix remaining mqtt calculation
2023-06-11 Read more distances
2023-06-20 Optional features can be controlled via platformio.ini and are mentioned in firmware name on MQTT
2023-08-02 gpio 15 warnung
2023-08-02 increase ota partition size for newer platform core
2023-09-09 wiP Please enter the commit message for your changes. Lines starting
2023-09-10 remove no longer working ulp timedlight
2023-09-26 12v layout tests
2023-10-10 layouting continued
2023-10-15 add charging circuit
2023-10-21 updated layout
2023-10-22 added batterymanagemt
2023-10-26 finalize
2023-11-01 finalize layout for comparator
2023-11-19 ignore netlist
2023-11-20 adjust folder to be shorter
2023-11-21 proceeed further
2023-11-21 adjustments
2023-11-26 adjust compile stuff
2023-11-27 use vergen
2023-11-29 adjusted partitions
2023-11-29 config start
2023-11-29 partition table
2023-12-07 file write test
2023-12-12 wifi config file handling added
2023-12-19 fix reverse protection diodes
2023-12-22 initial config changes
2023-12-22 more javascript shit
2023-12-23 move to typescript, testmode, shiftregister revival
2023-12-27 webserver improvements
2024-01-07 go to stay alive
2024-01-07 clippy
2024-01-10 set mppt output voltage to be less agressive
2024-01-17 add i2c initial and pull configs
2024-01-22 fix for bq34z100 led mode, added i2c header
